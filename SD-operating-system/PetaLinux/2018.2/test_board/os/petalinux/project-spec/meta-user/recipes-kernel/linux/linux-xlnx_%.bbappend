SRC_URI += "file://user_2018-08-09-17-01-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

